options:
  parameters:
    generate_options: qt_gui
    id: InterceptingReceiver_Task2
    output_language: python
    title: InterceptingReceiver_Task2
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '44200'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '15000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_imag_1
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1000, 1000)
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\GithubRepositories\COMP6841\Project_SomethingAwesome\Project\radio\GNURadio\WeatherBroadcast\WeatherRadio_T2_RE.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: C:\GithubRepositories\COMP6841\Project_SomethingAwesome\Project\radio\GNURadio\WeatherBroadcast\WeatherRadio_T2_IM.wav
    repeat: 'True'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.2'
    seed: '0'
    taps: '1.0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """
          RANDU-based spreading block for continuous complex audio/QAM.

          Input:
              complex64 baseband signal, I + jQ

          Output:
              complex64 spread signal

          The RANDU state is converted into a binary chip:
              +1 or -1

          One chip is held for samples_per_chip input samples.
          """

          def __init__(self, samples_per_chip=10, seed=1):
              gr.sync_block.__init__(
                  self,
                  name="RANDU Phase Shifter",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.samples_per_chip = max(1, int(samples_per_chip))

              # RANDU should not be started from zero.
              self.state = int(seed) & 0x7FFFFFFF

              if self.state == 0:
                  self.state = 1

              # Using an odd seed is more representative of RANDU.
              if self.state % 2 == 0:
                  self.state += 1

              self.current_chip = np.complex64(1.0 + 0.0j)
              self.chip_sample_counter = 0

          def next_randu(self):
              """
              RANDU recurrence:

                  x[n+1] = 65539*x[n] mod 2^31
              """

              self.state = (65539 * self.state) & 0x7FFFFFFF
              return self.state

          def generate_chip(self):
          	state = self.next_randu()

          	# Select two relatively high state bits.
          	phase_index = (state >> 28) & 0x03

          	phase_table = (
              	np.complex64(1.0 + 0.0j),
              	np.complex64(0.0 + 1.0j),
              	np.complex64(-1.0 + 0.0j),
              	np.complex64(0.0 - 1.0j)
          	)

          	return phase_table[phase_index]

          def work(self, input_items, output_items):
              x = input_items[0]
              y = output_items[0]

              for i in range(len(x)):

                  # Generate a new chip at the chip-rate boundary.
                  if self.chip_sample_counter == 0:
                      self.current_chip = self.generate_chip()

                  # Apply the same sign change to I and Q.
                  y[i] = x[i] * self.current_chip

                  self.chip_sample_counter += 1

                  if self.chip_sample_counter >= self.samples_per_chip:
                      self.chip_sample_counter = 0

              return len(y)
    samples_per_chip: '10'
    seed: '1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    update_time: '0.001'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_stream_mux_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_stream_mux_0, '1']
- [blocks_complex_to_imag_1, '0', audio_sink_0, '0']
- [blocks_float_to_complex_0, '0', blocks_complex_to_imag_1, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_float_to_complex_0, '0', epy_block_0, '0']
- [blocks_multiply_xx_0, '0', channels_channel_model_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_multiply_xx_0_0, '0', blocks_multiply_xx_0, '0']
- [blocks_stream_mux_0, '0', blocks_multiply_xx_0, '1']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_1, '0', blocks_float_to_complex_0, '1']
- [channels_channel_model_0, '0', qtgui_time_sink_x_0, '0']
- [channels_channel_model_0, '0', qtgui_waterfall_sink_x_0, '0']
- [epy_block_0, '0', blocks_multiply_xx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
