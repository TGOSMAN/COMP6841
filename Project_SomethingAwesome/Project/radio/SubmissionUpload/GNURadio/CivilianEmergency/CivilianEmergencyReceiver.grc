options:
  parameters:
    author: Signal Forge
    category: '[Signal Forge]'
    description: Live civilian emergency audio with Barker-13 synchronisation and CRC-16/CCITT
    generate_options: no_gui
    id: CivilianEmergencyReceiver
    output_language: python
    title: Civilian Emergency Receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Live audio/metadata sample rate
    value: '44100'
  states: {}
- name: live_emergency_source
  id: epy_block
  parameters:
    _source_code: |-
      import math
      import os
      import numpy as np
      from gnuradio import gr

      BARKER_13 = (1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1)

      def crc16_ccitt(data, initial=0xffff):
          crc = initial
          for value in data:
              crc ^= value << 8
              for _ in range(8):
                  crc = ((crc << 1) ^ 0x1021) & 0xffff if crc & 0x8000 else (crc << 1) & 0xffff
          return crc

      class blk(gr.sync_block):
          """Live alert audio followed by Barker-13 and CRC-16 protected metadata."""
          def __init__(self, sample_rate=44100, symbol_samples=40, samples_per_hop=11025):
              gr.sync_block.__init__(
                  self,
                  name="Live Emergency Audio + Barker-13 + CRC-16",
                  in_sig=None,
                  out_sig=[np.complex64],
              )
              self.sample_rate = float(sample_rate)
              self.symbol_samples = int(symbol_samples)
              self.samples_per_hop = int(samples_per_hop)
              self.challenge_id = os.environ.get("SIGNAL_FORGE_CHALLENGE_ID", "civilian-emergency-intercept")
              payload = b"CIVIC-7|NORTH-SECTOR|EVACUATE|AUTH"
              crc = crc16_ccitt(payload)
              framed = payload + crc.to_bytes(2, "big")
              assert crc16_ccitt(framed[:-2]) == int.from_bytes(framed[-2:], "big")
              bits = tuple(1 if value & (1 << bit) else -1 for value in framed for bit in range(7, -1, -1))
              self.symbols = BARKER_13 + bits
              self.sample_index = 0
              self.metadata_phase = 0.0
              self.hop_phase = 0.0

          def set_sample_rate(self, sample_rate):
              self.sample_rate = float(sample_rate)

          def work(self, input_items, output_items):
              output = output_items[0]
              offsets = (-12000.0, -4000.0, 6000.0, 14000.0)
              for index in range(len(output)):
                  absolute = self.sample_index + index
                  symbol = self.symbols[(absolute // self.symbol_samples) % len(self.symbols)]
                  audio = 0.44 * math.sin(2 * math.pi * 640 * absolute / self.sample_rate)
                  audio += 0.28 * math.sin(2 * math.pi * 960 * absolute / self.sample_rate)
                  metadata = complex(math.cos(self.metadata_phase), math.sin(self.metadata_phase)) * symbol * 0.24
                  hop = offsets[(absolute // self.samples_per_hop) % len(offsets)]
                  carrier = complex(math.cos(self.hop_phase), math.sin(self.hop_phase))
                  output[index] = np.complex64((complex(audio, audio * 0.18) + metadata) * carrier)
                  self.metadata_phase = math.fmod(self.metadata_phase + 2 * math.pi * 3200 / self.sample_rate, 2 * math.pi)
                  self.hop_phase = math.fmod(self.hop_phase + 2 * math.pi * hop / self.sample_rate, 2 * math.pi)
              self.sample_index += len(output)
              return len(output)
    comment: CRC-16 is appended after the payload; Barker-13 precedes the complete frame.
    sample_rate: samp_rate
    samples_per_hop: '11025'
    symbol_samples: '40'
  states: {}
- name: channel_model
  id: channels_channel_model
  parameters:
    comment: Weather-station-style impaired live channel
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.08'
    seed: '6841'
    taps: 1.0, 0.12 + 0.04j
  states: {}
- name: signal_forge_live_sink
  id: epy_block
  parameters:
    _source_code: |-
      import os
      import sys
      from pathlib import Path
      sys.path.insert(0, str(Path(__file__).resolve().parents[1]))
      from signal_forge_live_sink import SignalForgeLiveSink

      class blk(SignalForgeLiveSink):
          def __init__(self, center_hz=169650000, sample_rate_hz=44100):
              super().__init__(
                  challenge_id=os.environ.get("SIGNAL_FORGE_CHALLENGE_ID", "civilian-emergency-intercept"),
                  center_hz=center_hz,
                  sample_rate_hz=sample_rate_hz,
                  source_label="CivilianEmergencyReceiver.py post-channel-model CF32",
                  modulation="AM audio plus Barker-13 BPSK metadata",
                  framing="BARKER13",
                  integrity="CRC16_CCITT",
              )
    center_hz: '169650000'
    comment: Streams live CF32 only; no File Sink or recorded data.
    sample_rate_hz: samp_rate
  states: {}

connections:
- [live_emergency_source, '0', channel_model, '0']
- [channel_model, '0', signal_forge_live_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
